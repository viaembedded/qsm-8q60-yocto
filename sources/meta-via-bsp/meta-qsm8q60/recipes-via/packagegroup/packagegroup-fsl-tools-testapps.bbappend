RDEPENDS_${PN}_remove = "fsl-rc-local"
