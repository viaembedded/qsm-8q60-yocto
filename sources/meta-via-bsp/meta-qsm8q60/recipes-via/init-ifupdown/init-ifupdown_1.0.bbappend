# Append path for freescale layer to replace interfaces
FILESEXTRAPATHS_prepend_imx6qsm8q60 := "${THISDIR}/${PN}:"
