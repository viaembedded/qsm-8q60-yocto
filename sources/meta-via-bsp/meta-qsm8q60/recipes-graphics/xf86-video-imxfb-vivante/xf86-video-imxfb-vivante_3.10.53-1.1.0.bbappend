# Copyright (C) 2015 VIA Technologies,Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://QSM8Q60_xdriver.patch"
